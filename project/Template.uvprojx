# Keil uVision project Template.uvprojx, settings and files
target 52840DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.1
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\code;..\code\sdk\components;..\code\sdk\components\ble\ble_advertising;..\code\sdk\components\ble\ble_link_ctx_manager;..\code\sdk\components\ble\ble_racp;..\code\sdk\components\ble\ble_services\ble_nus;..\code\sdk\components\ble\common;..\code\sdk\components\ble\nrf_ble_gatt;..\code\sdk\components\ble\nrf_ble_qwr;..\code\sdk\components\ble\peer_manager;..\code\sdk\components\boards;..\code\sdk\components\libraries\atomic;..\code\sdk\components\libraries\atomic_fifo;..\code\sdk\components\libraries\atomic_flags;..\code\sdk\components\libraries\balloc;..\code\sdk\components\libraries\bootloader\ble_dfu;..\code\sdk\components\libraries\bsp;..\code\sdk\components\libraries\button;..\code\sdk\components\libraries\cli;..\code\sdk\components\libraries\crc16;..\code\sdk\components\libraries\crc32;..\code\sdk\components\libraries\crypto;..\code\sdk\components\libraries\csense;..\code\sdk\components\libraries\csense_drv;..\code\sdk\components\libraries\delay;..\code\sdk\components\libraries\ecc;..\code\sdk\components\libraries\experimental_section_vars;..\code\sdk\components\libraries\experimental_task_manager;..\code\sdk\components\libraries\fds;..\code\sdk\components\libraries\fifo;..\code\sdk\components\libraries\fstorage;..\code\sdk\components\libraries\gfx;..\code\sdk\components\libraries\gpiote;..\code\sdk\components\libraries\hardfault;..\code\sdk\components\libraries\hci;..\code\sdk\components\libraries\led_softblink;..\code\sdk\components\libraries\log;..\code\sdk\components\libraries\log\src;..\code\sdk\components\libraries\low_power_pwm;..\code\sdk\components\libraries\mem_manager;..\code\sdk\components\libraries\memobj;..\code\sdk\components\libraries\mutex;..\code\sdk\components\libraries\pwr_mgmt;..\code\sdk\components\libraries\queue;..\code\sdk\components\libraries\ringbuf;..\code\sdk\components\libraries\scheduler;..\code\sdk\components\libraries\slip;..\code\sdk\components\libraries\sortlist;..\code\sdk\components\libraries\spi_mngr;..\code\sdk\components\libraries\stack_guard;..\code\sdk\components\libraries\strerror;..\code\sdk\components\libraries\svc;..\code\sdk\components\libraries\timer;..\code\sdk\components\libraries\twi_mngr;..\code\sdk\components\libraries\twi_sensor;..\code\sdk\components\libraries\uart;..\code\sdk\components\libraries\util;..\code\sdk\components\softdevice\common;..\code\sdk\components\softdevice\s140\headers\nrf52;..\code\sdk\components\softdevice\s140\headers;..\code\sdk\external\fprintf;..\code\sdk\external\segger_rtt;..\code\sdk\external\utf_converter;..\code\sdk\integration\nrfx;..\code\sdk\integration\nrfx\legacy;..\code\sdk\modules\nrfx;..\code\sdk\modules\nrfx\drivers\include;..\code\sdk\modules\nrfx\hal;..\code\sdk\modules\nrfx\mdk;..\code\app
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  link misc: --diag_suppress 6330
  group nrf_ble
    ../code/sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../code/sdk/components/ble/ble_advertising/: ble_advertising.c
    ../code/sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../code/sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nrf_drivers
    ../code/sdk/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_uart.c nrfx_gpiote.c nrfx_uarte.c
    ../code/sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../code/sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../code/sdk/modules/nrfx/soc/: nrfx_atomic.c
  group nrf_libraries
    ../code/sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../code/sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    ../code/sdk/components/libraries/memobj/: nrf_memobj.c
    ../code/sdk/components/libraries/atomic/: nrf_atomic.c
    ../code/sdk/components/libraries/balloc/: nrf_balloc.c
    ../code/sdk/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../code/sdk/components/libraries/strerror/: nrf_strerror.c
    ../code/sdk/components/libraries/button/: app_button.c
    ../code/sdk/components/libraries/scheduler/: app_scheduler.c
    ../code/sdk/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../code/sdk/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../code/sdk/components/libraries/hardfault/: hardfault_implementation.c
    ../code/sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../code/sdk/components/libraries/atomic_flags/: nrf_atflags.c
    ../code/sdk/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../code/sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../code/sdk/components/libraries/sortlist/: nrf_sortlist.c
  group nrf_log
    ../code/sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nrf_segger_rtt
    ../code/sdk/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nrf_softdevice
    ../code/sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group converter
    ../code/sdk/external/utf_converter/: utf.c
  group board_definition
    ../code/sdk/components/boards/: boards.c
  group board_support
    ../code/sdk/components/libraries/bsp/: bsp.c
  group app
    ../code/app/: main.c
    ../code/: sdk_config.h
target flash_s140_nrf52_7.0.1_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.1
  cpu: as above
  output: s140_nrf52_7.0.1_softdevice.hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --reduce_paths
  c include: ..\code;..\code\sdk\components;..\code\sdk\components\ble\ble_advertising;..\code\sdk\components\ble\ble_link_ctx_manager;..\code\sdk\components\ble\ble_racp;..\code\sdk\components\ble\ble_services\ble_nus;..\code\sdk\components\ble\common;..\code\sdk\components\ble\nrf_ble_gatt;..\code\sdk\components\ble\nrf_ble_qwr;..\code\sdk\components\ble\peer_manager;..\code\sdk\components\boards;..\code\sdk\components\libraries\atomic;..\code\sdk\components\libraries\atomic_fifo;..\code\sdk\components\libraries\atomic_flags;..\code\sdk\components\libraries\balloc;..\code\sdk\components\libraries\bootloader\ble_dfu;..\code\sdk\components\libraries\bsp;..\code\sdk\components\libraries\button;..\code\sdk\components\libraries\cli;..\code\sdk\components\libraries\crc16;..\code\sdk\components\libraries\crc32;..\code\sdk\components\libraries\crypto;..\code\sdk\components\libraries\csense;..\code\sdk\components\libraries\csense_drv;..\code\sdk\components\libraries\delay;..\code\sdk\components\libraries\ecc;..\code\sdk\components\libraries\experimental_section_vars;..\code\sdk\components\libraries\experimental_task_manager;..\code\sdk\components\libraries\fds;..\code\sdk\components\libraries\fifo;..\code\sdk\components\libraries\fstorage;..\code\sdk\components\libraries\gfx;..\code\sdk\components\libraries\gpiote;..\code\sdk\components\libraries\hardfault;..\code\sdk\components\libraries\hci;..\code\sdk\components\libraries\led_softblink;..\code\sdk\components\libraries\log;..\code\sdk\components\libraries\log\src;..\code\sdk\components\libraries\low_power_pwm;..\code\sdk\components\libraries\mem_manager;..\code\sdk\components\libraries\memobj;..\code\sdk\components\libraries\mutex;..\code\sdk\components\libraries\pwr_mgmt;..\code\sdk\components\libraries\queue;..\code\sdk\components\libraries\ringbuf;..\code\sdk\components\libraries\scheduler;..\code\sdk\components\libraries\slip;..\code\sdk\components\libraries\sortlist;..\code\sdk\components\libraries\spi_mngr;..\code\sdk\components\libraries\stack_guard;..\code\sdk\components\libraries\strerror;..\code\sdk\components\libraries\svc;..\code\sdk\components\libraries\timer;..\code\sdk\components\libraries\twi_mngr;..\code\sdk\components\libraries\twi_sensor;..\code\sdk\components\libraries\uart;..\code\sdk\components\libraries\util;..\code\sdk\components\softdevice\common;..\code\sdk\components\softdevice\s140\headers;..\code\sdk\components\softdevice\s140\headers\nrf52;..\code\sdk\external\fprintf;..\code\sdk\external\segger_rtt;..\code\sdk\external\utf_converter;..\code\sdk\integration\nrfx;..\code\sdk\integration\nrfx\legacy;..\code\sdk\modules\nrfx;..\code\sdk\modules\nrfx\drivers\include;..\code\sdk\modules\nrfx\hal;..\code\sdk\modules\nrfx\mdk;..\code\app
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.1
